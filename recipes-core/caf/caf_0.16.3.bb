# SPDX-License-Identifier: MIT
# Copyright (C) 2021 iris-GmbH infrared & intelligent sensors

require recipes-core/caf/caf.inc

SRCREV = "ec6a89271472aa7e45cfb72d483fd8cfce0210ac"
